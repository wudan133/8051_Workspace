# Keil uVision project FirmwareRom.uvproj, settings and files
target MS2100_AV2USB (MCS-51)
  device: R80515 Evatronix
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MODC2 MDU_R515
  output: usbispcode +hex
  c flags: Optimize=7
  c include: .\inc
  group main
    ./code/: STARTUP.A51 main.c usbrequest.c descript.c
