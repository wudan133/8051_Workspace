# Keil uVision project GPIO_UART.uvproj, settings and files
target Target 1 (MCS-51)
  device: ms8005A macrosilicon
  cpu: IRAM(0-0xFF) XRAM(0-0x800) IROM(0-0x8000) CLOCK(16000000)  MODC2 MDU_R515
  output: GPIO_UART +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
